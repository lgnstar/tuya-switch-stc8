# Keil uVision project switch-stc8.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: switch-stc8 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\mcu_sdk
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./mcu_sdk/: mcu_api.c protocol.c system.c
